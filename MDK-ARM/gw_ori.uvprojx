# Keil uVision project gw_ori.uvprojx, settings and files
target gw_ori (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: gw_ori
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,LWIP_DEBUG,MBEDTLS_CONFIG_FILE=<mbedtls_config.h>
  c include: ../Inc;                    ../Middlewares/Third_Party/LwIP/src/include;                    ../Middlewares/Third_Party/LwIP/system;                    ../Drivers/STM32F4xx_HAL_Driver/Inc;                    ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                    ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;                    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                    ../Middlewares/Third_Party/FreeRTOS/Source/include;                    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                    ../Middlewares/Third_Party/LwIP/src/include/lwip;                    ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;                    ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;                    ../Middlewares/Third_Party/LwIP/src/include/lwip/prot;                    ../Middlewares/Third_Party/LwIP/src/include/netif;                    ../Middlewares/Third_Party/LwIP/src/include/posix;                    ../Middlewares/Third_Party/LwIP/src/include/posix/sys;                    ../Middlewares/Third_Party/LwIP/system/arch;                    ../Drivers/CMSIS/Include;              ../Middlewares/Third_Party/LwIP/src/apps/httpd;        ../Middlewares/Third_Party/mbedTLS/include;        ../Middlewares/Third_Party/mbedTLS/include/mbedtls
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c stm32f4xx_hal_timebase_TIM.c stm32f4xx_it.c stm32f4xx_hal_msp.c lwip.c freertos.c ethernetif.c webserver.c modbus_master.c modbus_slave.c mbedtls.c net_sockets.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_eth.c stm32f4xx_hal_pwr.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal.c stm32f4xx_hal_rtc.c stm32f4xx_hal_crc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_uart.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash_ex.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c event_groups.c list.c queue.c timers.c croutine.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: fsm.c pppcrypt.c pppapi.c mppe.c pppol2tp.c vj.c demand.c ipv6cp.c pppos.c ppp.c chap-md5.c multilink.c eui64.c ccp.c auth.c utils.c upap.c chap_ms.c lcp.c ipcp.c eap.c pppoe.c chap-new.c magic.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c err.c tcpip.c netifapi.c netdb.c netbuf.c api_msg.c sockets.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: ip6_addr.c ip6.c dhcp6.c inet6.c icmp6.c nd6.c ethip6.c ip6_frag.c mld6.c
    ../Middlewares/Third_Party/LwIP/src/core/: raw.c tcp_out.c sys.c memp.c tcp.c tcp_in.c timeouts.c udp.c mem.c stats.c inet_chksum.c pbuf.c def.c ip.c init.c netif.c dns.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c ip4_addr.c ip4.c dhcp.c icmp.c ip4_frag.c etharp.c igmp.c
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c lowpan6.c slipif.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
    ../Middlewares/Third_Party/LwIP/src/apps/sntp/: sntp.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../Middlewares/Third_Party/LwIP/src/apps/httpd/: httpd.c fs.c
  group Middlewares/mbedTLS
    ../Middlewares/Third_Party/mbedTLS/library/: md_wrap.c certs.c x509write_csr.c havege.c ssl_ticket.c x509_crl.c pkparse.c threading.c pkwrite.c ctr_drbg.c cmac.c ssl_tls.c rsa.c md5.c xtea.c ssl_srv.c oid.c platform.c padlock.c ssl_cli.c dhm.c aesni.c debug.c ecp_curves.c x509_crt.c pem.c ecp.c x509_csr.c camellia.c x509.c ecdsa.c md2.c memory_buffer_alloc.c bignum.c gcm.c asn1parse.c ecjpake.c pkcs11.c x509_create.c hmac_drbg.c asn1write.c blowfish.c cipher_wrap.c aes.c pkcs12.c ssl_cache.c base64.c pk.c entropy_poll.c timing.c md4.c sha1.c ccm.c x509write_crt.c ssl_cookie.c cipher.c ripemd160.c ecdh.c version.c arc4.c entropy.c version_features.c ssl_ciphersuites.c des.c sha256.c pkcs5.c pk_wrap.c error.c sha512.c md.c
software components: CMSIS:CORE 5.1.1, Compiler:I/O:STDOUT 1.4.0
